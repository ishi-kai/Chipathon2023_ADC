v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 220 -280 0 0 {name=p1 lab=CLK}
C {devices/opin.sym} 440 -360 0 0 {name=p2 lab=COMP_CLK}
C {devices/opin.sym} 440 -300 0 0 {name=p3 lab=SC}
C {devices/ipin.sym} 220 -300 0 0 {name=p5 lab=XRST}
C {devices/ipin.sym} 220 -240 0 0 {name=p7 lab=COMP_OUT}
C {devices/opin.sym} 440 -340 0 0 {name=p6 lab=DIGITAL_OUT}
C {devices/ipin.sym} 220 -360 0 0 {name=p8 lab=vccd1}
C {devices/ipin.sym} 220 -340 0 0 {name=p9 lab=vssd1}
C {devices/opin.sym} 440 -260 0 0 {name=p10 lab=SDAC[7]}
C {devices/opin.sym} 440 -280 0 0 {name=p12 lab=SDAC[8]}
C {devices/opin.sym} 440 -240 0 0 {name=p4 lab=SDAC[6]}
C {devices/opin.sym} 440 -200 0 0 {name=p11 lab=SDAC[4]}
C {devices/opin.sym} 440 -220 0 0 {name=p13 lab=SDAC[5]}
C {devices/opin.sym} 440 -180 0 0 {name=p14 lab=SDAC[3]}
C {devices/opin.sym} 440 -140 0 0 {name=p15 lab=SDAC[1]}
C {devices/opin.sym} 440 -160 0 0 {name=p16 lab=SDAC[2]}
C {devices/opin.sym} 440 -120 0 0 {name=p17 lab=SDAC[0]}
